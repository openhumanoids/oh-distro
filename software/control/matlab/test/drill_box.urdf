Commit message: Making collision juuuuust smaller than visual

File: software/control/matlab/test/drill_box.urdf (robot description, URDF)
Before this commit: robot drill_box, 1 links, 0 joints
Links:
- link drill_box: geometry collision box size=0.0599 0.0599 0.19; collision sphere radius=0
