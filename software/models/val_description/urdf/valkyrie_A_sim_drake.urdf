Commit message: another few fixes due to drake bugs

File: software/models/val_description/urdf/valkyrie_A_sim_drake.urdf (robot description, URDF)
Before this commit: robot valkyrie, 87 links, 86 joints
Joints:
- joint hokuyo_joint: type continuous -> fixed
